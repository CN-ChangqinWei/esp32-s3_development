## test/sdkconfig.defaults
```kconfig
# 测试工程固定目标芯片：sdkconfig 被 .gitignore 忽略，
# 全新克隆若无本文件会退化为默认 esp32，导致构建出错误架构的固件。
CONFIG_IDF_TARGET="esp32c3"
```
